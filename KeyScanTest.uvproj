# Keil uVision project KeyScanTest.uvproj, settings and files
target KeyScanTest (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: KeyScanTest +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Includes
  group User
    ./Sources/: main.c
  group Driver
    ./Sources/: Uart.c KeyScan.c
